# Keil uVision project CyberryPotter.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CyberryPotter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c misc: -Wno-nan-infinity-disabled
  c include: .\CNN\nnom_lib\inc;.\CNN\nnom_lib\inc\layers;.\CNN\nnom_lib\port;.\CNN;.\MainBoard;.\MainBoard\eMPL;.\Module
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group nnom
    ./CNN/: weights.h
    ./CNN/nnom_lib/inc/: nnom.h nnom_layers.h nnom_local.h nnom_tensor.h nnom_utils.h
    ./CNN/nnom_lib/inc/layers/: nnom_activation.h nnom_avgpool.h nnom_baselayer.h nnom_concat.h nnom_conv2d.h nnom_conv2d_trans.h nnom_cropping.h nnom_dense.h nnom_dw_conv2d.h nnom_flatten.h nnom_global_pool.h nnom_gru_cell.h nnom_input.h nnom_lambda.h nnom_lstm_cell.h nnom_matrix.h nnom_maxpool.h nnom_output.h nnom_reshape.h nnom_rnn.h nnom_simple_cell.h nnom_softmax.h nnom_sumpool.h nnom_upsample.h nnom_zero_padding.h
    ./CNN/nnom_lib/port/: nnom_port.h
    ./CNN/nnom_lib/src/backends/: nnom_local.c nnom_local_q15.c
    ./CNN/nnom_lib/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ./CNN/nnom_lib/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_reshape.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
  group MainBoard
    ./MainBoard/: config.h CyberryPotter.c CyberryPotter.h CyberryPotter_status.h Delay.c Delay.h IIC.c IIC.h IMU.c IMU.h main.c MPU6050.c MPU6050.h MPU6050_Reg.h W25Q64.c W25Q64.h SPI.c SPI.h USART.c USART.h button.c button.h LED.c LED.h ADC.c ADC.h
    ./MainBoard/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group Module
    ./Module/: module0_IR.c module0_IR.h module1_RF433.c module1_RF433.h module2_RF315.c module2_RF315.h module_IR_RF.c module_IR_RF.h module3.c module3.h module4.c module4.h module5.c module5.h module6.c module6.h module7.c module7.h module8.c module8.h module9.c module9.h module10.c module10.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
