<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SensorTag.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SensorTag</project>
        <configuration>CC2541DK-Sensor</configuration>
      </member>
      <member>
        <project>SensorTag</project>
        <configuration>CC2541DK-Sensor-OAD-ImgA</configuration>
      </member>
      <member>
        <project>SensorTag</project>
        <configuration>CC2541DK-Sensor-OAD-ImgB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


