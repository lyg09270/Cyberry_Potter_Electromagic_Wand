<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OADManager.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>OADManager</project>
        <configuration>CC2540EM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


